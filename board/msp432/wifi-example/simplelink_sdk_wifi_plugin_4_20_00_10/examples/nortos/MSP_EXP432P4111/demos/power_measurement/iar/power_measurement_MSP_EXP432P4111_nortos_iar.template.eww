<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/power_measurement_MSP_EXP432P4111_nortos_iar.ewp</path>
  </project>
  <batchBuild/>
</workspace>
